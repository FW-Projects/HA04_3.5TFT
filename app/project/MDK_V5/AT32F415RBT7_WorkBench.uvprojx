# Keil uVision project AT32F415RBT7_WorkBench.uvprojx, settings and files
target AT32F415RBT7_WorkBench (6230000::V6.23::ARMCLANG)
  device: -AT32F415RBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F415RBT7_WorkBench +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  AfterMake: D:\AT32_project\FWS2ProMax_TFT2.8-master\app\project\MDK_V5\keil5_disp_size_bar.exe
  c flags: Optim=7 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: AT32F415RBT7,USE_STDPERIPH_DRIVER
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\app;..\device;..\src;..\system;..\TFT2.8
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c wk_system.c wk_adc.c wk_debug.c wk_spi.c wk_tmr.c wk_usart.c wk_wdt.c wk_dma.c wk_gpio.c wk_crc.c
  group firmware
    ../../libraries/drivers/src/: at32f415_adc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_pwc.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_wdt.c at32f415_crc.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ./: startup_at32f415.s
  group app
    ../app/: HA01_handle.c beep_handle.c flash_handle.c iap.c key_handle.c output_handle.c PC_comm_handle.c lcd_handle.c ec11_handle.c
  group device
    ../device/: adc_filter.c at32_spiflash.c at32_Usart.c beep.c fan.c flash.c key.c util_queue.c lcd.c EncoderEC11.c adc.c
  group system
    ../system/: PID_operation.c tmt.c
